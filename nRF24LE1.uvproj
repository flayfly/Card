# Keil uVision project nRF24LE1.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: nRF24LE1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\air LCD remote;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\c51;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24le1
  group Source Group 1
    ./: STARTUP.A51 Main.c hal_delay.c
